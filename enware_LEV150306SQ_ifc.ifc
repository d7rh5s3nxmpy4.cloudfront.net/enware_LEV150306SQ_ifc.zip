Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-10-29T14:34:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 29 14:34:19 2019 * Host: DESKTOP-M2LI49J * Database: C:\Users\PC-026\AppData\Local\Temp\{E95C87A3-EF0F-4F8A-AF4C-4C3EA4BF39B4}\ifc * Database version: 5507 * Database creation date: Tue Oct 29 14:34:19 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 29 14:34:19 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 29 14:34:19 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: \\192.168.1.99\Production\2019\Dante\Working\Revit Family\LEV150306SQ\Project1.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 ft; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: LEV150306SQ, LEV150306SQ:LEV150306SQ:41750
In: Level 1
Pset_DistributionFlowElementCommon - Reference: LEV150306SQ
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 ft
Dimensions - Area: 0.02678 m2; Volume: 0.000363432 m3
Identity Data - Mark: 17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: LEV150306SQ
Other - Category: Plumbing Fixtures; Family: LEV150306SQ: LEV150306SQ; Family and Type: LEV150306SQ: LEV150306SQ; Type: LEV150306SQ: LEV150306SQ; Type Id: LEV150306SQ: LEV150306SQ; Family Name: LEV150306SQ
Phasing - Phase Created: New Construction
